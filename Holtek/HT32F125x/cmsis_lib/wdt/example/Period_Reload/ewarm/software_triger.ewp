# IAR project software_triger.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: Default None
  ICCARM.CCDefines: ewarm
  ICCARM.CCIncludePath2: ../../../../lib/Include; ../../../../lib/cmsis_core; ../../../../lib/cmsis_boot; ../../../../lib/cmsis_boot/srart/iar; ../src
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ILINK.IlinkOutputFile: led.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath: dl-stnl0.a
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group cmsis_boot
    ../../../../lib/cmsis_boot/: ht32f125x.h system_ht32f125x.c system_ht32f125x.h
  group cmsis_boot/startup
    ../../../../lib/cmsis_boot/startup/iar/: startup_ht32f125x.s
  group cmsis_core
    ../../../../lib/cmsis_core/: core_cm3.c core_cm3.h
  group cmsis_lib/include
    ../../../../lib/Include/: ht32f125x_ckcu.h ht32f125x_gpio.h ht32f125x_misc.h ht32f125x_rstcu.h ht32f125x_usart.h ht32f125x_wdt.h
  group cmsis_lib/source
    ../../../../lib/Src/: ht32f125x_ckcu.c ht32f125x_gpio.c ht32f125x_misc.c ht32f125x_rstcu.c ht32f125x_usart.c ht32f125x_wdt.c
  group src
    ../: main.c
    ../src/: Period_Reload.c
