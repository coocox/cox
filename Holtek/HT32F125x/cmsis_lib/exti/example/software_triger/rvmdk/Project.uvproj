# Keil uVision project Project.uvproj, settings and files
target HT32F1253_DVB (ARM-ADS)
  device: HT32F1253 Holtek
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x00000000-0x00007BFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: HT32F1253_DVB +hex
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: USE_HT32F1253_DVB
  c include: ..\..\..\..\lib\cmsis_boot;..\..\..\..\lib\cmsis_boot\startup\arm;..\..\..\..\lib\Include;..\src
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x7c00
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --entry Reset_Handler
  group cmsis_core
    ../../../../lib/cmsis_core/: core_cm3.c core_cm3.h
  group cmsis_boot
    ../../../../lib/cmsis_boot/: ht32f125x.h system_ht32f125x.c system_ht32f125x.h
  group rvmdk
    ../../../../lib/cmsis_boot/startup/arm/: startup_ht32f125x.s
  group include
    ../../../../lib/Include/: ht32f125x_adc.h ht32f125x_ckcu.h ht32f125x_cmp_op.h ht32f125x_exti.h ht32f125x_flash.h ht32f125x_gpio.h ht32f125x_gptm.h ht32f125x_i2c.h ht32f125x_misc.h ht32f125x_pwrcu.h ht32f125x_rstcu.h ht32f125x_rtc.h ht32f125x_spi.h ht32f125x_usart.h ht32f125x_wdt.h
  group source
    ../../../../lib/Src/: ht32f125x_adc.c ht32f125x_ckcu.c ht32f125x_cmp_op.c ht32f125x_exti.c ht32f125x_flash.c ht32f125x_gpio.c ht32f125x_gptm.c ht32f125x_i2c.c ht32f125x_misc.c ht32f125x_pwrcu.c ht32f125x_rstcu.c ht32f125x_rtc.c ht32f125x_spi.c ht32f125x_usart.c ht32f125x_wdt.c
  group example
    ../src/: software_triger.c
  group usr
    ../: main.c
