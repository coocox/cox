# IAR project template.ewp, settings and files
configuration Debug_Flash (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: NUC140xE Nuvoton NUC140xE
  ICCARM.CCDefines: ewarm
  ICCARM.CCIncludePath2: ..\..\..\lib\include; ..\..\..\lib\cmsis_core; ..\..\..\lib\cmsis_boot\startup\iar; ..\..\..\lib\cmsis_boot
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: template.srec
  ILINK.IlinkOutputFile: template.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Debug_Ram (ARM, debug)
  as the first configuration, except:
  ICCARM.CCIncludePath2: ..\..\..\..\lib\Include; ..\..\..\..\lib\Include\Driver; ..\..\..\..\lib\Include\System; ..\..\..\..\lib\cmsis_boot; ..\..\..\..\lib\cmsis_core
  OBJCOPY.OOCOutputFile: sample_sys.srec
  ILINK.IlinkIcfFile: nuc1xx_ram.icf
  group cmsis_boot
    ../../../lib/cmsis_boot/: ht32f125x.h system_ht32f125x.c system_ht32f125x.h
  group cmsis_boot/startup
    ../../../lib/cmsis_boot/startup/iar/: startup_ht32f125x.s
  group cmsis_core
    ../../../lib/cmsis_core/: core_cm3.c core_cm3.h
  group cmsis_lib/include
    ../../../lib/Include/: ht32f125x_adc.h ht32f125x_ckcu.h ht32f125x_cmp_op.h ht32f125x_exti.h ht32f125x_flash.h ht32f125x_gpio.h ht32f125x_gptm.h ht32f125x_i2c.h ht32f125x_misc.h ht32f125x_pwrcu.h ht32f125x_rstcu.h ht32f125x_rtc.h ht32f125x_spi.h ht32f125x_usart.h ht32f125x_wdt.h
  group cmsis_lib/source
    ../../../lib/Src/: ht32f125x_adc.c ht32f125x_ckcu.c ht32f125x_cmp_op.c ht32f125x_exti.c ht32f125x_flash.c ht32f125x_gpio.c ht32f125x_gptm.c ht32f125x_i2c.c ht32f125x_misc.c ht32f125x_pwrcu.c ht32f125x_rstcu.c ht32f125x_rtc.c ht32f125x_spi.c ht32f125x_usart.c ht32f125x_wdt.c
  group document/adc
    ../../../adc/document/: adc.xml description.html
  group document/ckcu
    ../../../ckcu/document/: ckcu.xml description.html
  group document/cmp_op
    ../../../cmp_op/document/: cmp_op.xml description.html
  group document/exti
    ../../../exti/document/: description.html exti.xml
  group document/fmc
    ../../../fmc/document/: description.html fmc.xml
  group document/gpio
    ../../../gpio/document/: description.html gpio.xml
  group document/gptm
    ../../../gptm/document/: description.html gptm.xml
  group document/i2c
    ../../../i2c/document/: description.html i2c.xml
  group document/misc
    ../../../misc/document/: description.html misc.xml
  group document/pwrcu
    ../../../pwrcu/document/: description.html pwrcu.xml
  group document/rstcu
    ../../../rstcu/document/: description.html rstcu.xml
  group document/rtc
    ../../../rtc/document/: description.html rtc.xml
  group document/spi
    ../../../spi/document/: description.html spi.xml
  group document/usart
    ../../../usart/document/: description.html usart.xml
  group document/wdt
    ../../../wdt/document/: description.html wdt.xml
  group Source
    ../src/: main.c
