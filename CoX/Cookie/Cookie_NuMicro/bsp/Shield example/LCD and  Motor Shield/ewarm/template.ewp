# IAR project template.ewp, settings and files
configuration Debug_Flash (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: M0516 Nuvoton M0516
  ICCARM.CCDefines: ewarm; xDEBUG
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\CoX_Peripheral\CoX_Peripheral_M051\libcox; ..\..\..\..\libshining; ..\..\..\..\..\..\Driver\LCD_Character\HD44780\Character_LCD_HD44780_Driver\lib; ..\..\..\..\..\..\Driver\Memory_SDCard\SDCard\SDCard_SPI_Driver\lib
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: template.srec
  ILINK.IlinkOutputFile: template.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Debug_Ram (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: NUC140xE Nuvoton NUC140xE
  ICCARM.CCDefines: ewarm
  ICCARM.CCIncludePath2: ..\..\..\..\libcox
  ILINK.IlinkIcfFile: nuc1xx_ram.icf
  group Co-Shining
    ../../../../libshining/: coshining.h coshining_cfg.h
  group CoX/CoX_Driver/SDCard
    ../../../../../../Driver/Memory_SDCard/SDCard/SDCard_SPI_Driver/lib/: hw_sdcard.h sdcard.c sdcard.h
  group CoX/CoX_Driver/HD44780
    ../../../../../../Driver/LCD_Character/HD44780/Character_LCD_HD44780_Driver/lib/: hd44780.c hd44780.h hw_hd44780.h
  group CoX/CoX_Peripheral/inc
    ../../../../../../CoX_Peripheral/CoX_Peripheral_M051/libcox/: xacmp.h xadc.h xcore.h xdebug.h xgpio.h xhw_acmp.h xhw_adc.h xhw_gpio.h xhw_i2c.h xhw_ints.h xhw_memmap.h xhw_nvic.h xhw_pwm.h xhw_spi.h xhw_sysctl.h xhw_timer.h xhw_types.h xhw_uart.h xhw_wdt.h xi2c.h xpwm.h xspi.h xsysctl.h xtimer.h xuart.h xwdt.h
  group CoX/CoX_Peripheral/src
    ../../../../../../CoX_Peripheral/CoX_Peripheral_M051/libcox/: xacmp.c xadc.c xcore.c xdebug.c xgpio.c xi2c.c xpwm.c xspi.c xsysctl.c xtimer.c xuart.c xwdt.c
  group ewarm
    ./: startup_ewarm.s
  group Source
    ../: main.c
