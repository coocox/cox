# Keil uVision project template.uvproj, settings and files
target Debug_Flash (ARM-ADS)
  device: M0516LAN Nuvoton
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0-0x0FFFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: template
  c flags: Optim=1
  c define: xDEBUG
  c include: ..\..\..\..\..\..\CoX_Peripheral\CoX_Peripheral_M051\libcox;..\..\..\..\libshining;..\..\..\..\..\..\Driver\LCD_Character\HD44780\Character_LCD_HD44780_Driver\lib;..\..\..\..\..\..\Driver\Memory_SDCard\SDCard\SDCard_SPI_Driver\lib
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x1000
  scatter file: .\m051_flash.sct
  link misc: --entry ResetHandler
  group rvmdk
    ./: startup_rvmdk.s
  group libcox_inc
    ../../../../../../CoX_Peripheral/CoX_Peripheral_M051/libcox/: xcore.h xdebug.h xgpio.h xhw_gpio.h xhw_i2c.h xhw_ints.h xhw_memmap.h xhw_nvic.h xhw_pwm.h xhw_spi.h xhw_sysctl.h xhw_timer.h xhw_types.h xhw_uart.h xi2c.h xpwm.h xspi.h xsysctl.h xtimer.h xuart.h xwdt.h xhw_wdt.h xacmp.h xadc.h xhw_acmp.h xhw_adc.h
  group libcox_src
    ../../../../../../CoX_Peripheral/CoX_Peripheral_M051/libcox/: xcore.c xgpio.c xi2c.c xpwm.c xspi.c xsysctl.c xuart.c xdebug.c xwdt.c xtimer.c xacmp.c xadc.c
  group Co-Shining
    ../../../../libshining/: coshining.h coshining_cfg.h
  group Source
    ../: main.c
  group SD_lib
    ../../../../../../Driver/Memory_SDCard/SDCard/SDCard_SPI_Driver/lib/: hw_sdcard.h sdcard.c sdcard.h
  group LCD_lib
    ../../../../../../Driver/LCD_Character/HD44780/Character_LCD_HD44780_Driver/lib/: hd44780.c hd44780.h hw_hd44780.h
target Debug_Ram (ARM-ADS)
  device: NUC140LD3AN Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x0FFFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: template
  c flags: Optim=1 OneElfS=1
  c include: ..\..\..\..\..\..\CoX_Peripheral\CoX_Peripheral_M051\libcox;..\..\..\..\libshining
  memory RVCT4: ROM 0x20000000 size 0x2000
  memory RVCT9: RAM 0x20002000 size 0x2000
  scatter file: .\m051_ram.sct
  link misc: --entry ResetHandler
