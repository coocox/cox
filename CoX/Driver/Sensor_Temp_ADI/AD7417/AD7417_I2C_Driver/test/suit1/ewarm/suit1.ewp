# IAR project suit1.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: NUC140xE Nuvoton NUC140xE
  ICCARM.CCDefines: ewarm; xDEBUG
  ICCARM.CCIncludePath2: ../../../lib; ../src; ../../../../../../../CoX_Peripheral\CoX_Peripheral_NUC1xx\testframe; ../../../../../../../CoX_Peripheral\CoX_Peripheral_NUC1xx\libcox; ../../../../../../resource/testframe; ../../../../../../../CoX_Peripheral\CoX_Peripheral_NUC1xx\startup
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: template.srec
  ILINK.IlinkOutputFile: template.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: ../../../../../../../../CoX\CoX_Peripheral\CoX_Peripheral_NUC1xx\libcox; ../../../../../../../../CoX\CoX_Peripheral\CoX_Peripheral_NUC1xx\testframe; ../../../../../../../../CoX\CoX_Peripheral\CoX_Peripheral_NUC1xx\sysctl\test\suite1\src
  ICCARM.CCOptLevel: 3
  group CoX/CoX_Driver/Sensor_Temp_AD7417
    ../../../lib/: ad7417.c ad7417.h xhw_ad7417.h
  group CoX/CoX_Peripheral/inc
    ../../../../../../../CoX_Peripheral/CoX_Peripheral_NUC1xx/libcox/: xadc.h xcore.h xdebug.h xgpio.h xhw_gpio.h xhw_i2c.h xhw_ints.h xhw_memmap.h xhw_nvic.h xhw_sysctl.h xhw_types.h xhw_uart.h xi2c.h xsysctl.h xuart.h
  group CoX/CoX_Peripheral/src
    ../../../../../../../CoX_Peripheral/CoX_Peripheral_NUC1xx/libcox/: xcore.c xdebug.c xgpio.c xi2c.c xsysctl.c xuart.c
  group ewarm
    ../../../../../../../CoX_Peripheral/CoX_Peripheral_NUC1xx/startup/src/: startup_ewarm.s
  group test/testcase
    ../src/: AD7417test1.c AD7417test2.c AD7417test3.c testcase.c testcase.h
  group test/testframe
    ../../../../../../../resource/testframe/: main.c test.c test.h testport.c
