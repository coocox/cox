# Keil uVision project suite1_nuc1xx.uvproj, settings and files
target Debug_Flash (ARM-ADS)
  device: NUC140LE3AN Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: suite1_nuc1xx
  c flags: Optim=1
  c define: xDEBUG
  c include: ..\..\..\..\..\..\..\CoX_Peripheral\CoX_Peripheral_NUC1xx\libcox;..\src;..\..\..\lib
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: .\nuc1xx_flash.sct
  link misc: --entry ResetHandler
  group rvmdk
    ./: startup_rvmdk.s
  group libcox_inc
    ../../../../../../../CoX_Peripheral/CoX_Peripheral_NUC1xx/libcox/: xi2c.h xcore.h xdebug.h xgpio.h xhw_gpio.h xhw_ints.h xhw_memmap.h xhw_nvic.h xhw_sysctl.h xhw_types.h xhw_uart.h xsysctl.h xuart.h xhw_i2c.h
  group libcox_src
    ../../../../../../../CoX_Peripheral/CoX_Peripheral_NUC1xx/libcox/: xi2c.c xcore.c xdebug.c xgpio.c xsysctl.c xuart.c
  group AD7417
    ../../../lib/: ad7417.c ad7417.h xhw_AD7417.h
  group example
    ../src/: TempGet.c
  group source
    ../src/: main.c
target Debug_Ram (ARM-ADS)
  device: NUC140LD3AN Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x0FFFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: suite1_nuc1xx
  c flags: Optim=1 OneElfS=1
  c include: ..\..\..\..\..\..\..\CoX_Peripheral\CoX_Peripheral_NUC1xx\libcox;..\..\..\..\..\..\..\resource\testframe;..\src;..\..\..\lib
  memory RVCT4: ROM 0x20000000 size 0x2000
  memory RVCT9: RAM 0x20002000 size 0x2000
  scatter file: .\nuc1xx_ram.sct
  link misc: --entry ResetHandler
