# IAR project TempGet.ewp, settings and files
configuration Debug_Flash (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: NUC140xE Nuvoton NUC140xE
  ICCARM.CCDefines: ewarm; xDEBUG; TEST_IO_PORT_BOARD=TEST_IO_PORT_NUC1XX
  ICCARM.CCIncludePath2: ../../../lib; ../src; ../../../../../../../CoX_Peripheral\CoX_Peripheral_NUC1xx\libcox; ../../../../../../../CoX_Peripheral\CoX_Peripheral_NUC1xx\startup
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: template.srec
  ILINK.IlinkOutputFile: template.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Debug_Ram (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LM3SxBxx TexasInstruments LM3SxBxx
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\..\..\CoX\CoX_Peripheral\CoX_Peripheral_LM3S\libcox
  ILINK.IlinkIcfFile: stellaris_ram.icf
  group CoX/CoX_Peripheral/inc
    ../../../../../../../CoX_Peripheral/CoX_Peripheral_NUC1xx/libcox/: xcore.h xdebug.h xgpio.h xhw_gpio.h xhw_i2c.h xhw_ints.h xhw_memmap.h xhw_nvic.h xhw_sysctl.h xhw_types.h xhw_uart.h xi2c.h xsysctl.h xuart.h
  group CoX/CoX_Peripheral/src
    ../../../../../../../CoX_Peripheral/CoX_Peripheral_NUC1xx/libcox/: xcore.c xdebug.c xgpio.c xi2c.c xsysctl.c xuart.c
  group CoX/CoX_Driver/Sensor_Temp_AD7417
    ../../../lib/: ad7417.c ad7417.h xhw_AD7417.h
  group document
    ../../../../../../../CoX_Peripheral/CoX_Peripheral_LM3S/startup/document/: startup.xml
  group ewarm
    ../../../../../../../CoX_Peripheral/CoX_Peripheral_NUC1xx/startup/src/: startup_ewarm.s
  group example
    ../src/: TempGet.c
  group Source
    ../src/: main.c
