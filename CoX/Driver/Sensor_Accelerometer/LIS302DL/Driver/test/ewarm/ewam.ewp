# IAR project ewam.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F107xC ST STM32F107xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: ewarm
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\Cox_Peripheral\CoX_Peripheral_STM32F1xx\libcox; ..\src; ..\..\lib
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: ewam.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group app
    ../: main.c
    ../src/: test.c test.h
  group driver
    ../../lib/: hw_LIS302DL.h LIS302DL.c LIS302DL.h
  group libcox
    ../../../../../../CoX_Peripheral/CoX_Peripheral_STM32F1xx/libcox/: xcore.c xcore.h xdebug.c xdebug.h xgpio.c xgpio.h xhw_config.h xhw_gpio.h xhw_i2c.h xhw_ints.h xhw_memmap.h xhw_sysctl.h xhw_types.h xhw_uart.h xi2c.c xi2c.h xsysctl.c xsysctl.h xuart.c xuart.h
  group startup
    ../../../../../../CoX_Peripheral/CoX_Peripheral_STM32F1xx/startup/src/: startup_ewarm.s
