# IAR project M24CxxExample.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: STM32F107xC ST STM32F107xC
  ICCARM.CCIncludePath2: ../../../../../../../CoX_Peripheral\CoX_Peripheral_STM32F1xx\libcox; ../../../lib; ../src; ../../../../../../resource\testframe
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: M24CxxExample.srec
  ILINK.IlinkOutputFile: M24CxxExample.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group COX/CoX_Driver/M24Cxx
    ../../../lib/: hw_M24Cxx.h M24Cxx.c M24Cxx.h
  group COX/CoX_Peripheral/inc
    ../../../../../../../CoX_Peripheral/CoX_Peripheral_STM32F1xx/libcox/: xcore.h xdebug.h xgpio.h xhw_gpio.h xhw_i2c.h xhw_ints.h xhw_memmap.h xhw_nvic.h xhw_sysctl.h xhw_types.h xhw_uart.h xi2c.h xsysctl.h xuart.h xwdt.h
  group COX/CoX_Peripheral/src
    ../../../../../../../CoX_Peripheral/CoX_Peripheral_STM32F1xx/libcox/: xcore.c xgpio.c xi2c.c xsysctl.c xuart.c
  group ewarm
    ../../../../../../../CoX_Peripheral/CoX_Peripheral_STM32F1xx/startup/src/: startup_ewarm.s
  group Example
    ../src/: Example.c
  group Source
    ../: main.c
