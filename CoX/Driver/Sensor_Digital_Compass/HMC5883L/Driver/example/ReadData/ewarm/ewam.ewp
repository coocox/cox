# IAR project ewam.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xE ST STM32F103xE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: ewarm
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\..\Cox_Peripheral\CoX_Peripheral_STM32F1xx\libcox; ..\src; ..\..\..\lib
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: ewam.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group app
    ../: main.c
    ../src/: ReadData.c
  group driver
    ../../../lib/: HMC5883L.c HMC5883L.h hw_HMC5883L.h
  group libcox
    ../../../../../../../CoX_Peripheral/CoX_Peripheral_STM32F1xx/libcox/: xcore.c xdebug.c xgpio.c xi2c.c xsysctl.c xuart.c
  group startup
    ../../../../../../../CoX_Peripheral/CoX_Peripheral_STM32F1xx/startup/src/: startup_ewarm.s
