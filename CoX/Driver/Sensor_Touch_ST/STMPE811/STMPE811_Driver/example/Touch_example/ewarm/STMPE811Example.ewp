# IAR project STMPE811Example.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: STM32F107xC ST STM32F107xC
  ICCARM.CCIncludePath2: ../../../../../../../CoX_Peripheral\CoX_Peripheral_STM32F1xx\libcox; ../../../lib; ../src; ../../../../../../../CoX_Peripheral\CoX_Peripheral_STM32F1xx\testframe; ../../../../../../LCD_Character/HX8347-G/Character_LCD_HX8347-G_Driver/lib
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: STMPE811Example.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group COX/CoX_Driver/HX8347-G
    ../../../../../../LCD_Character/HX8347-G/Character_LCD_HX8347-G_Driver/lib/: hw_HX8347-G.h HX8347-G.c HX8347-G.h
  group COX/CoX_Driver/STMPE811
    ../../../lib/: hw_STMPE811.h STMPE811.c STMPE811.h
  group COX/CoX_Peripheral/inc
    ../../../../../../../CoX_Peripheral/CoX_Peripheral_STM32F1xx/libcox/: xcore.h xdebug.h xgpio.h xhw_gpio.h xhw_i2c.h xhw_ints.h xhw_memmap.h xhw_spi.h xhw_sysctl.h xhw_types.h xhw_uart.h xi2c.h xspi.h xsysctl.h xuart.h
  group COX/CoX_Peripheral/src
    ../../../../../../../CoX_Peripheral/CoX_Peripheral_STM32F1xx/libcox/: xcore.c xdebug.c xgpio.c xi2c.c xspi.c xsysctl.c xuart.c
  group ewarm
    ../../../../../../../CoX_Peripheral/CoX_Peripheral_STM32F1xx/startup/src/: startup_ewarm.s
  group Example
    ../src/: Example.c
  group Source
    ../: main.c
