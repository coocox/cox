# IAR project template.ewp, settings and files
configuration Debug_Flash (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: NUC140xE Nuvoton NUC140xE
  ICCARM.CCDefines: ewarm
  ICCARM.CCIncludePath2: ../../../../../../../CoX_Peripheral\CoX_Peripheral_NUC1xx\libcox; ../src; ../../../lib; ../../../../../../resource\testframe
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: template.srec
  ILINK.IlinkOutputFile: template.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Debug_Ram (ARM, debug)
  as the first configuration, except:
  ICCARM.CCIncludePath2: ..\..\..\..\libcox
  ILINK.IlinkIcfFile: nuc1xx_ram.icf
  group CoX/CoX_Driver/w25Xxx
    ../../../lib/: hw_w25xxx.h w25xxx.c w25xxx.h
  group CoX/CoX_Peripheral/inc
    ../../../../../../../CoX_Peripheral/CoX_Peripheral_NUC1xx/libcox/: xcore.h xgpio.h xhw_gpio.h xhw_ints.h xhw_memmap.h xhw_nvic.h xhw_spi.h xhw_sysctl.h xhw_types.h xhw_uart.h xspi.h xsysctl.h xuart.h
  group CoX/CoX_Peripheral/src
    ../../../../../../../CoX_Peripheral/CoX_Peripheral_NUC1xx/libcox/: xcore.c xgpio.c xspi.c xsysctl.c xuart.c
  group ewarm
    ./: startup_ewarm.s
  group Source
    ../: main.c
  group w25XxxRW
    ../src/: w25xxReadWrite.c w25xxReadWrite.h
