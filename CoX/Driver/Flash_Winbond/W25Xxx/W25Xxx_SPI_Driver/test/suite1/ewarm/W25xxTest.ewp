# IAR project W25xxTest.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: NUC140xE Nuvoton NUC140xE
  ICCARM.CCDefines: ewarm
  ICCARM.CCIncludePath2: ../../../../../../../CoX_Peripheral\CoX_Peripheral_NUC1xx\libcox; ../../../lib; ../src; ../../../../../../../../resource\test\testframe
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ILINK.IlinkOutputFile: W25xxTest.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath: dl-stnl0.a
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group CoX/CoX_Driver/W25Xxx
    ../../../lib/: hw_W25Xxx.h w25xxx.c w25xxx.h
  group CoX/CoX_Peripheral/inc
    ../../../../../../../CoX_Peripheral/CoX_Peripheral_NUC1xx/libcox/: xcore.h xgpio.h xhw_gpio.h xhw_ints.h xhw_memmap.h xhw_nvic.h xhw_spi.h xhw_sysctl.h xhw_types.h xhw_uart.h xspi.h xsysctl.h xuart.h
  group CoX/CoX_Peripheral/src
    ../../../../../../../CoX_Peripheral/CoX_Peripheral_NUC1xx/libcox/: xcore.c xgpio.c xspi.c xsysctl.c xuart.c
  group ewarm
    ./: startup_ewarm.s
  group test/testcase
    ../src/: testcase.c testcase.h w25xxTest.c
  group test/testframe
    ../../../../../../../resource/testframe/: main.c test.c test.h testport.c
