# Keil uVision project MCP9824x_EEPROM_WR.uvproj, settings and files
target MCP9824x_EEPROM_WR (ARM-ADS)
  device: NUC140VE3AN Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: MCP9824x_EEPROM_WR
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  c flags: Optim=1
  c include: ..\..\..\..\..\..\..\CoX_Peripheral\CoX_Peripheral_NUC1xx\libcox;..\..\..\lib
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --entry Reset_Handler
  group rvmdk
    ./: startup_NUC1xx.s
  group src
    D:/work/svn.cox/trunk/CoX/CoX_Peripheral/CoX_Peripheral_NUC1xx/libcox/: xgpio.c xi2c.c xsysctl.c
    ../../../../../../../CoX_Peripheral/CoX_Peripheral_NUC1xx/libcox/: xcore.c
  group driver
    ../../../lib/: MCP98242_3.c MCP98242_3.h hw_MCP98242_3.h
  group example
    ../src/: main.c MCP9824x_EEPROM_WR.c
