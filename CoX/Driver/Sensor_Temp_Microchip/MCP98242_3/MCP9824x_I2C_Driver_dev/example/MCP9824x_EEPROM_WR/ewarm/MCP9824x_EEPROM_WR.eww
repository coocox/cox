<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\MCP9824x_EEPROM_WR.ewp</path>
  </project>
  <batchBuild/>
</workspace>


