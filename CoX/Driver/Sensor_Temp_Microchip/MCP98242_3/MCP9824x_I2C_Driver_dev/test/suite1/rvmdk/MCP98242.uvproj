# Keil uVision project MCP98242.uvproj, settings and files
target MCP98242 (ARM-ADS)
  device: NUC140VE3AN Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: MCP98242
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  c flags: Optim=1
  c include: ..\..\..\..\..\..\..\CoX_Peripheral\CoX_Peripheral_NUC1xx\libcox;..\..\..\lib;..\..\..\..\..\..\..\resource\testframe;..\src
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --entry Reset_Handler
  group rvmdk
    ./: startup_NUC1xx.s
  group libcox
    ../../../../../../../CoX_Peripheral/CoX_Peripheral_NUC1xx/libcox/: xcore.h xdebug.h xdma.h xgpio.h xhw_dma.h xhw_gpio.h xhw_i2c.h xhw_ints.h xhw_memmap.h xhw_nvic.h xhw_rtc.h xhw_spi.h xhw_sysctl.h xhw_types.h xhw_uart.h xi2c.h xrtc.h xspi.h xsysctl.h xuart.h xcore.c
  group src
    ../../../../../../../CoX_Peripheral/CoX_Peripheral_NUC1xx/libcox/: xgpio.c xi2c.c xsysctl.c xuart.c
  group driver
    ../../../lib/: MCP98242_3.c MCP98242_3.h hw_MCP98242_3.h
  group test
    ../src/: testcase.c xmcp98242test.c
    ../../../../../../../resource/testframe/: test.c testport.c main.c
