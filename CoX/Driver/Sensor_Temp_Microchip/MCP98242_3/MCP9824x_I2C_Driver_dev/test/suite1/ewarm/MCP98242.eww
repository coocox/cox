<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\MCP98242.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\..\example\MCP9824x_EEPROM_WR\ewarm\MCP9824x_EEPROM_WR.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\..\example\TempSensor_Event\ewarm\TempSensor_Event.ewp</path>
  </project>
  <batchBuild/>
</workspace>


