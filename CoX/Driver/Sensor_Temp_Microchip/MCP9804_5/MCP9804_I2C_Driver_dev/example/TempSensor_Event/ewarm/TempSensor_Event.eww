<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\..\..\..\test\suite1\ewarm\MCP9804.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\TempSensor_Event.ewp</path>
  </project>
  <batchBuild/>
</workspace>


