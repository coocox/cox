# Keil uVision project TC74TempGet.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: NUC140VE3AN Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: TC74_Test
  c flags: Optim=1
  c include: ..\..\..\lib;..\src;..\..\..\..\..\..\..\CoX_Peripheral\CoX_Peripheral_NUC1xx\libcox
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group startup
    ./: startup_rvmdk.S
  group libcox
    ../../../../../../../CoX_Peripheral/CoX_Peripheral_NUC1xx/libcox/: xi2c.c xsysctl.c xcore.c xgpio.c
  group src
    ../src/: TC74TempGet.c main.c
  group TC74
    ../../../lib/: xhw_TC74.h TC74.c TC74.h
