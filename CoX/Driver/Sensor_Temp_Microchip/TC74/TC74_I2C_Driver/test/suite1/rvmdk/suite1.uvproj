# Keil uVision project suite1.uvproj, settings and files
target Debug_Flash (ARM-ADS)
  device: NUC140VE3AN Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: TC74_Test
  c flags: Optim=1
  c include: ..\..\..\lib;..\src;..\..\..\..\..\..\..\CoX_Peripheral\CoX_Peripheral_NUC1xx\testframe;..\..\..\..\..\..\..\CoX_Peripheral\CoX_Peripheral_NUC1xx\libcox
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group rvmdk
    ./: startup_rvmdk.S
  group libcox
    ../../../../../../../CoX_Peripheral/CoX_Peripheral_NUC1xx/libcox/: xuart.c xgpio.c xi2c.c xsysctl.c xcore.c
  group testcase
    ../src/: TC74 _Test.c testcase.c testcase.h
  group testframe
    ../../../../../../../CoX_Peripheral/CoX_Peripheral_NUC1xx/testframe/: main.c test.c test.h testport.c
  group tc74
    ../../../lib/: xhw_TC74.h TC74.c TC74.h
