# IAR project suite1.ewp, settings and files
configuration Debug_Flash (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: NUC140xE Nuvoton NUC140xE
  ICCARM.CCDefines: ewarm
  ICCARM.CCIncludePath2: ../../../../../../../CoX_Peripheral\CoX_Peripheral_NUC1xx\libcox; ../../../lib; ../src; ../../../../../../../CoX_Peripheral\CoX_Peripheral_NUC1xx\testframe
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: template.srec
  ILINK.IlinkOutputFile: template.out
  ILINK.IlinkIcfFile: nuc1xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Debug_Ram (ARM, debug)
  as the first configuration, except:
  ICCARM.CCIncludePath2: ..\..\..\..\libcox
  ILINK.IlinkIcfFile: nuc1xx_ram.icf
  group CoX/CoX_Peripheral/inc
    ../../../../../../../CoX_Peripheral/CoX_Peripheral_NUC1xx/libcox/: xcore.h xdebug.h xgpio.h xhw_memmap.h xhw_sysctl.h xhw_types.h xi2c.h xuart.h
  group CoX/CoX_Peripheral/src
    ../../../../../../../CoX_Peripheral/CoX_Peripheral_NUC1xx/libcox/: xcore.c xgpio.c xi2c.c xsysctl.c xuart.c
  group CoX/TC74
    ../../../lib/: TC74.c TC74.h xhw_TC74.h
  group ewarm
    ./: startup_ewarm.s
  group testframe
    ../../../../../../../CoX_Peripheral/CoX_Peripheral_NUC1xx/testframe/: main.c test.c test.h testport.c
  group testcase
    ../src/: TC74 _Test.c testcase.c testcase.h
