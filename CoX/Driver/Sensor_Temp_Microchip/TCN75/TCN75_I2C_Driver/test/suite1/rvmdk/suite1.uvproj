# Keil uVision project suite1.uvproj, settings and files
target Debug_Flash (ARM-ADS)
  device: NUC140VE3AN Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: TC74_Test
  c flags: Optim=1
  c include: ..\..\..\lib;..\src;..\..\..\..\..\..\..\resource\testframe;..\..\..\..\..\..\..\CoX_Peripheral\CoX_Peripheral_NUC1xx\libcox
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: .\nuc1xx_flash.sct
  group rvmdk
    ./: startup_NUC1xx.s
  group libcox
    ../../../../../../../CoX_Peripheral/CoX_Peripheral_NUC1xx/libcox/: xuart.c xgpio.c xi2c.c xsysctl.c xcore.c
  group testcase
    ../src/: testcase.c testcase.h TCN75 _Test.c
  group testframe
    ../../../../../../../resource/testframe/: main.c test.c test.h testport.c
  group tcn75
    ../../../lib/: xhw_TCN75.h TCN75.c TCN75.h
