# IAR project suite1_M0516.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: M0516 Nuvoton M0516
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: ../src; ../../../Co_Shining\; ../../../lib\; ../../../../../../CoX_Peripheral\CoX_Peripheral_M051\libcox\; ../../../../../../CoX_Peripheral\CoX_Peripheral_M051\startup\src; ../../../../../../CoX_Peripheral\CoX_Peripheral_M051\testframe\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: suite1_M0516.srec
  ILINK.IlinkOutputFile: suite1_M0516.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\Nuvoton\M0516.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Co_Shining
    ../../../Co_Shining/: coshining.h coshining_cfg.h
  group CoX/inc
    ../../../../../../CoX_Peripheral/CoX_Peripheral_M051/libcox/: xcore.h xdebug.h xgpio.h xhw_gpio.h xhw_ints.h xhw_memmap.h xhw_nvic.h xhw_timer.h xhw_types.h xhw_uart.h xsysctl.h xtimer.h xuart.h
  group CoX/src
    ../../../../../../CoX_Peripheral/CoX_Peripheral_M051/libcox/: xcore.c xdebug.c xgpio.c xsysctl.c xtimer.c xuart.c
  group DotMatrix
    ../../../lib/: Dot_Matrix.c Dot_Matrix.h font.h
  group Source
    ../src/: DotMatrix_Test.c testcase.c testcase.h
  group startup
    ../../../../../../CoX_Peripheral/CoX_Peripheral_M051/startup/src/: startup_ewarm.s
  group testframe
    ../../../../../../CoX_Peripheral/CoX_Peripheral_M051/testframe/: main.c test.c test.h testport.c
