# Keil uVision project suite1_M0516.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: M0516LAN Nuvoton
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0-0x0FFFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: suite1_M0516
  c flags: Optim=1
  c include: ..\src;..\..\..\Co_Shining;..\..\..\..\..\CoX_Peripheral\CoX_Peripheral_M051\startup\src;..\..\..\..\..\CoX_Peripheral\CoX_Peripheral_M051\libcox;..\..\..\..\..\CoX_Peripheral\CoX_Peripheral_M051\testframe;..\..\..\lib
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --entry ResetHandler
  group startup
    ../../../../../CoX_Peripheral/CoX_Peripheral_M051/startup/src/: startup_rvmdk.s
  group lib_inc
    ../../../../../CoX_Peripheral/CoX_Peripheral_M051/libcox/: xuart.h xcore.h xdebug.h xgpio.h xhw_gpio.h xhw_ints.h xhw_memmap.h xhw_nvic.h xhw_sysctl.h xhw_timer.h xhw_types.h xhw_uart.h xsysctl.h xtimer.h
  group lib_src
    ../../../../../CoX_Peripheral/CoX_Peripheral_M051/libcox/: xuart.c xcore.c xdebug.c xgpio.c xspi.c xsysctl.c xtimer.c
  group source
    ../src/: main.c
  group testframe
    ../../../lib/: uart.c
  group Co_Shining
    ../../../Co_Shining/: coshining.h coshining_cfg.h
  group GPS
    ../../../lib/: gps.c
