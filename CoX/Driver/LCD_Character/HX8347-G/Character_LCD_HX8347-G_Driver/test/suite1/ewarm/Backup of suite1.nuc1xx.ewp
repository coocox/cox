# IAR project Backup of suite1.nuc1xx.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F107xC ST STM32F107xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ewarm
  ICCARM.CCIncludePath2: ../../../../../../../CoX_Peripheral\CoX_Peripheral_STM32F1xx\libcox; ../../../lib; ../src; ../../../../../../../CoX_Peripheral\CoX_Peripheral_STM32F1xx\testframe
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: suite1.nuc1xx.srec
  ILINK.IlinkOutputFile: W25xxTest.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ILINK.IlinkOutputFile: suite1.nuc1xx.out
  group COX/CoX_Driver/M24Cxx_IIC_Driver
    ../../../lib/: hw_M24Cxx.h M24Cxx.c M24Cxx.h
  group COX/CoX_Peripheral/inc
    ../../../../../../../CoX_Peripheral/CoX_Peripheral_STM32F1xx/libcox/: xcore.h xdebug.h xdma.h xgpio.h xhw_gpio.h xhw_i2c.h xhw_ints.h xhw_memmap.h xhw_nvic.h xhw_spi.h xhw_sysctl.h xhw_types.h xhw_uart.h xi2c.h xsysctl.h xuart.h
  group COX/CoX_Peripheral/src
    ../../../../../../../CoX_Peripheral/CoX_Peripheral_STM32F1xx/libcox/: xcore.c xdebug.c xgpio.c xi2c.c xsysctl.c xuart.c
  group ewarm
    ./: startup_ewarm.s
  group Source
    ../: main.c
  group test/testcase
    ../src/: M24CxxTest.c testcase.c testcase.h
  group test/testframe
    ../../../../../../../CoX_Peripheral/CoX_Peripheral_STM32F1xx/testframe/: test.c test.h testport.c
