<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\HX8347-GExample.ewp</path>
  </project>
  <batchBuild/>
</workspace>


