# IAR project suite1.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LM3S9B96 TexasInstruments LM3S9B96
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: ../../../../../../../CoX_Peripheral\CoX_Peripheral_LM3S\startup\src\; ../../../../../../../CoX_Peripheral\CoX_Peripheral_LM3S\libcox\; ../../../../../../../CoX_Peripheral\CoX_Peripheral_LM3S\testframe\; ../../../test\suite1\src; ../../../lib; 
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: suite1.srec
  ILINK.IlinkOutputFile: suite1.out
  ILINK.IlinkIcfFile: LM3S9B96.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group CoX/inc
    ../../../../../../../CoX_Peripheral/CoX_Peripheral_LM3S/libcox/: xcore.h xdebug.h xgpio.h xhw_gpio.h xhw_ints.h xhw_memmap.h xhw_nvic.h xhw_spi.h xhw_sysctl.h xhw_types.h xhw_uart.h xspi.h xsysctl.h xuart.h
  group CoX/src
    ../../../../../../../CoX_Peripheral/CoX_Peripheral_LM3S/libcox/: xcore.c xdebug.c xgpio.c xspi.c xsysctl.c xuart.c
  group ewarm
    ../../../../../../../CoX_Peripheral/CoX_Peripheral_LM3S/startup/src/: startup_ewarm.s
  group Source
    ../../../../../../../CoX_Peripheral/CoX_Peripheral_LM3S/testframe/: main.c test.c testport.c
  group ssd2119
    ../../../lib/: ssd2119.c
  group test
    ../src/: ssd2119test1.c testcase.c testcase.h
