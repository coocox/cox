# Keil uVision project suite1_M0516.uvproj, settings and files
target Debug_Flash (ARM-ADS)
  device: M0516LAN Nuvoton
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0-0x0FFFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: suite1_lm3sxx
  c flags: Optim=1
  c include: ..\src;..\..\..\lib;..\..\..\..\..\..\..\CoX_Peripheral\CoX_Peripheral_M051\libcox;..\..\..\..\..\..\..\CoX_Peripheral\CoX_Peripheral_M051\testframe
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --entry ResetHandler
  group startup
    ../../../../../../../CoX_Peripheral/CoX_Peripheral_M051/startup/src/: startup_rvmdk.s
  group testframe
    ../../../../../../../CoX_Peripheral/CoX_Peripheral_M051/testframe/: main.c test.c testport.c
  group st7735s
    ../../../lib/: st7735.c pic.c
  group test
    ../src/: testcase.c st7735stest.c
  group cox_inc
    ../../../../../../../CoX_Peripheral/CoX_Peripheral_M051/libcox/: xuart.h xcore.h xdebug.h xgpio.h xhw_gpio.h xhw_ints.h xhw_memmap.h xhw_nvic.h xhw_sysctl.h xhw_types.h xhw_uart.h xsysctl.h
  group cox_src
    ../../../../../../../CoX_Peripheral/CoX_Peripheral_M051/libcox/: xuart.c xcore.c xdebug.c xgpio.c xsysctl.c
