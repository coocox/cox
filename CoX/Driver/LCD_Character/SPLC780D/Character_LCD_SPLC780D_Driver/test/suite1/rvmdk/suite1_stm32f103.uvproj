# Keil uVision project suite1_stm32f103.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: suite1_stm32f103
  c flags: Optim=1
  c include: ..\src;..\..\..\..\..\..\..\CoX_Peripheral\CoX_Peripheral_STM32F1xx\libcox;..\..\..\..\..\..\..\CoX_Peripheral\CoX_Peripheral_STM32F1xx\startup\src;..\..\..\..\..\..\..\CoX_Peripheral\CoX_Peripheral_STM32F1xx\testframe;..\..\..\lib
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --entry ResetHandler
  group startup
    ../../../../../../../CoX_Peripheral/CoX_Peripheral_STM32F1xx/startup/src/: startup_rvmdk.s
  group cox_inc
    ../../../../../../../CoX_Peripheral/CoX_Peripheral_STM32F1xx/libcox/: xuart.h xcore.h xdebug.h xgpio.h xhw_config.h xhw_gpio.h xhw_i2c.h xhw_ints.h xhw_memmap.h xhw_nvic.h xhw_sysctl.h xhw_types.h xhw_uart.h xi2c.h xsysctl.h
  group cox_src
    ../../../../../../../CoX_Peripheral/CoX_Peripheral_STM32F1xx/libcox/: xuart.c xcore.c xdebug.c xgpio.c xi2c.c xsysctl.c
  group testframe
    ../../../../../../../CoX_Peripheral/CoX_Peripheral_STM32F1xx/testframe/: main.c test.c testport.c
  group source
    ../src/: testcase.c SPLC780Dtest.c
  group driver
    ../../../lib/: splc780d.c
