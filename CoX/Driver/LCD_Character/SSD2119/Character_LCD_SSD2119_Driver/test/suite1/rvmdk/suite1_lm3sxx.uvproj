# Keil uVision project suite1_lm3sxx.uvproj, settings and files
target Debug_Flash (ARM-ADS)
  device: LM3S9B96 Texas Instruments
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: suite1_lm3sxx
  c flags: Optim=1
  c include: ..\src;..\..\..\lib;..\..\..\..\..\..\..\CoX_Peripheral\CoX_Peripheral_LM3S\libcox;..\..\..\..\..\..\..\CoX_Peripheral\CoX_Peripheral_LM3S\testframe
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group rvmdk
    ../../../../../../../CoX_Peripheral/CoX_Peripheral_LM3S/startup/src/: startup_rvmdk.s
  group lib_inc
    ../../../../../../../CoX_Peripheral/CoX_Peripheral_LM3S/libcox/: xuart.h xcore.h xdebug.h xgpio.h xhw_gpio.h xhw_ints.h xhw_memmap.h xhw_nvic.h xhw_spi.h xhw_sysctl.h xhw_types.h xhw_uart.h xspi.h xsysctl.h
  group lib_src
    ../../../../../../../CoX_Peripheral/CoX_Peripheral_LM3S/libcox/: xuart.c xcore.c xdebug.c xgpio.c xspi.c xsysctl.c
  group Source
    ../../../../../../../CoX_Peripheral/CoX_Peripheral_LM3S/testframe/: main.c test.c testport.c
  group ssd2119
    ../../../lib/: ssd2119.c
  group test
    ../src/: ssd2119test1.c testcase.c
