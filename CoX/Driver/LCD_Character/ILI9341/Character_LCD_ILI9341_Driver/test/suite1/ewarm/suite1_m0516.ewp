# IAR project suite1_m0516.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: M0516 Nuvoton M0516
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: ../../../../../../..\CoX_Peripheral\CoX_Peripheral_M051\libcox; ../../../../../../..\CoX_Peripheral\CoX_Peripheral_M051\testframe; ../../../../../../..\CoX_Peripheral\CoX_Peripheral_M051\startup\src; ../../../lib; ../src
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: suite1_m0516.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group CoX/inc
    ../../../../../../../CoX_Peripheral/CoX_Peripheral_M051/libcox/: xcore.h xdebug.h xgpio.h xhw_gpio.h xhw_ints.h xhw_memmap.h xhw_nvic.h xhw_sysctl.h xhw_types.h xhw_uart.h xsysctl.h xuart.h
  group CoX/src
    ../../../../../../../CoX_Peripheral/CoX_Peripheral_M051/libcox/: xcore.c xdebug.c xgpio.c xsysctl.c xuart.c
  group ili9341
    ../../../lib/: 8X16.h GB1616.h GB3232.h hw_ili9341.h ili9341.c ili9341.h
  group source
    ../src/: ili9341test.c testcase.c testcase.h
  group startup
    ../../../../../../../CoX_Peripheral/CoX_Peripheral_M051/startup/src/: startup_ewarm.s
  group testframe
    ../../../../../../../CoX_Peripheral/CoX_Peripheral_M051/testframe/: main.c test.c test.h testport.c
