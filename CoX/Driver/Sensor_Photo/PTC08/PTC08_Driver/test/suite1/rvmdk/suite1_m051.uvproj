# Keil uVision project suite1_m051.uvproj, settings and files
target Debug_Flash (ARM-ADS)
  device: M0516LAN Nuvoton
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0-0x0FFFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: suite1_nuc1xx
  c flags: Optim=1
  c define: xDEBUG
  c include: ..\..\..\..\..\..\..\CoX_Peripheral\CoX_Peripheral_NUC1xx\libcox;..\..\..\..\..\..\..\resource\testframe;..\src;..\..\..\lib
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --entry ResetHandler
  group rvmdk
    ./: startup_rvmdk.s
  group libcox_inc
    ../../../../../../../CoX_Peripheral/CoX_Peripheral_M051/libcox/: xacmp.h xadc.h xcore.h xdebug.h xgpio.h xhw_acmp.h xhw_adc.h xhw_gpio.h xhw_i2c.h xhw_ints.h xhw_memmap.h xhw_nvic.h xhw_pwm.h xhw_spi.h xhw_sysctl.h xhw_timer.h xhw_types.h xhw_uart.h xhw_wdt.h xi2c.h xpwm.h xspi.h xsysctl.h xtimer.h xuart.h xwdt.h
  group libcox_src
    ../../../../../../../CoX_Peripheral/CoX_Peripheral_M051/libcox/: xacmp.c xadc.c xcore.c xdebug.c xgpio.c xi2c.c xpwm.c xspi.c xsysctl.c xtimer.c xuart.c xwdt.c
  group ptc08
    ../../../lib/: hw_PTC08.h PTC08.c PTC08.h
  group testframe
    ../../../../../../../resource/testframe/: main.c test.c test.h testport.c
  group testcase
    ../src/: test1.c testcase.c testcase.h
target Debug_Ram (ARM-ADS)
  device: M0516LAN Nuvoton
  cpu: as above
  output: suite1_nuc1xx
  c flags: Optim=1 OneElfS=1
  c include: as above
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --entry ResetHandler
