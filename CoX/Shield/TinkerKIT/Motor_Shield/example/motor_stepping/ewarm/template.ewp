# IAR project template.ewp, settings and files
configuration Debug_Flash (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xE ST STM32F103xE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ewarm
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\CoX_Peripheral\CoX_Peripheral_STM32F1xx\libcox; ..\..\..\..\..\..\Cookie\Embedded_pi\libcookie; ..\..\..\..\..\..\CoX_Peripheral\CoX_Peripheral_STM32F1xx\startup\src; ..\..\..\lib; ..\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: template.srec
  ILINK.IlinkOutputFile: template.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Debug_Ram (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  ICCARM.CCIncludePath2: ..\..\..\..\libcox
  ILINK.IlinkIcfFile: nuc1xx_ram.icf
  group Cookie
    ../../../../../../Cookie/Embedded_pi/libcookie/: cookie.h cookie_cfg.h
  group CoX/CoX_Peripheral/inc
    ../../../../../../CoX_Peripheral/CoX_Peripheral_STM32F1xx/libcox/: xcore.h xdebug.h xgpio.h xhw_config.h xhw_gpio.h xhw_ints.h xhw_memmap.h xhw_nvic.h xhw_sysctl.h xhw_timer.h xhw_types.h xhw_uart.h xpwm.h xsysctl.h xtimer.h xuart.h
  group CoX/CoX_Peripheral/src
    ../../../../../../CoX_Peripheral/CoX_Peripheral_STM32F1xx/libcox/: xcore.c xdebug.c xgpio.c xpwm.c xsysctl.c xtimer.c xuart.c
  group ewarm
    ../../../../../../CoX_Peripheral/CoX_Peripheral_STM32F1xx/startup/src/: startup_ewarm.s
  group MotorShield
    ../../../lib/: MotorShield.c MotorShield.h
  group Source
    ../: main.c
