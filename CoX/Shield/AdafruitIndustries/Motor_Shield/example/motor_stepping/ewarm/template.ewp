# IAR project template.ewp, settings and files
configuration Debug_Flash (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: M0516 Nuvoton M0516
  ICCARM.CCDefines: ewarm; xDEBUG
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\CoX_Peripheral\CoX_Peripheral_M051\libcox; ..\..\..\..\..\..\Shining\Shining_NuMicro\libshining; ..\..\..\..\..\..\CoX_Peripheral\CoX_Peripheral_M051\startup\src; ..\..\..\lib
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: template.srec
  ILINK.IlinkOutputFile: template.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Debug_Ram (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: NUC140xE Nuvoton NUC140xE
  ICCARM.CCDefines: ewarm
  ICCARM.CCIncludePath2: ..\..\..\..\libcox
  ILINK.IlinkIcfFile: nuc1xx_ram.icf
  group Co-Shining
    ../../../../../../Shining/Shining_NuMicro/libshining/: coshining.h coshining_cfg.h
  group CoX/CoX_Peripheral/inc
    ../../../../../../CoX_Peripheral/CoX_Peripheral_M051/libcox/: xcore.h xdebug.h xgpio.h xhw_gpio.h xhw_ints.h xhw_memmap.h xhw_nvic.h xhw_pwm.h xhw_sysctl.h xhw_timer.h xhw_types.h xpwm.h xsysctl.h xtimer.h
  group CoX/CoX_Peripheral/src
    ../../../../../../CoX_Peripheral/CoX_Peripheral_M051/libcox/: xcore.c xdebug.c xgpio.c xpwm.c xsysctl.c xtimer.c
  group ewarm
    ../../../../../../CoX_Peripheral/CoX_Peripheral_M051/startup/src/: startup_ewarm.s
  group MotorShield
    ../../../lib/: MotorShield.c MotorShield.h
  group Source
    ../: main.c
