# IAR project WiFi.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xC ST STM32F103xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCIncludePath2: ..\..\..\lib; ..\..\..\..\..\..\CoX_Peripheral\CoX_Peripheral_STM32F1xx\libcox
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: WiFi.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Cox_Lib/inc
    ../../../../../../CoX_Peripheral/CoX_Peripheral_STM32F1xx/libcox/: xacmp.h xadc.h xcore.h xdebug.h xdma.h xgpio.h xhw_adc.h xhw_config.h xhw_dma.h xhw_gpio.h xhw_i2c.h xhw_ints.h xhw_memmap.h xhw_nvic.h xhw_rtc.h xhw_spi.h xhw_sysctl.h xhw_timer.h xhw_types.h xhw_uart.h xhw_wdt.h xi2c.h xpwm.h xrtc.h xspi.h xsysctl.h xtimer.h xuart.h xwdt.h
  group Cox_Lib/src
    ../../../../../../CoX_Peripheral/CoX_Peripheral_STM32F1xx/libcox/: xadc.c xcore.c xdebug.c xdma.c xgpio.c xi2c.c xpwm.c xrtc.c xspi.c xsysctl.c xtimer.c xuart.c xwdt.c
  group Example
    ../../ConnectNoEncryption/src/: ConnectNoEncryption.c
  group startup
    ../../../../../../CoX_Peripheral/CoX_Peripheral_STM32F1xx/startup/src/: startup_ewarm.s
  group WiFi_Lib/inc
    ../../../lib/: server_drv.h spi_drv.h WiFi.h wifi_drv.h wifi_spi.h WiFiClient.h wl_definitions.h
  group WiFi_Lib/src
    ../../../lib/: server_drv.c spi_drv.c WiFi.c wifi_drv.c WiFiClient.c
