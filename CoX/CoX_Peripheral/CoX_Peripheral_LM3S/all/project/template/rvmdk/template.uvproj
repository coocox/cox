# Keil uVision project template.uvproj, settings and files
target Debug_Flash (ARM-ADS)
  device: LM3S9B96 Luminary Micro
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: template
  c flags: Optim=1
  c define: xDEBUG
  c include: ..\..\..\..\libcox
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x18000
  scatter file: .\stellaris_flash.sct
  link misc: --entry ResetHandler
  group rvmdk
    ../../../../startup/src/: startup_rvmdk.s
  group Source
    ../: main.c
target Debug_Ram (ARM-ADS)
  device: LM3S9B96 Luminary Micro
  cpu: as above
  output: template
  c flags: Optim=1 OneElfS=1
  c include: ..\..\..\..\libcox
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x18000
  scatter file: .\stellaris_ram.sct
  link misc: --entry ResetHandler
