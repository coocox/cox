# IAR project output.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: NUC140xE Nuvoton NUC140xE
  ICCARM.CCDefines: ewarm; XDEBUG; DEBUG
  ICCARM.CCIncludePath2: ../../../../../../../CoX\CoX_Peripheral\CoX_Peripheral_NUC1xx\libcox; ../../../../../../../CoX\CoX_Peripheral\CoX_Peripheral_NUC1xx\testframe; ../../../../../../../CoX\CoX_Peripheral\CoX_Peripheral_NUC1xx\gpio\test\suite1\src
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ILINK.IlinkOutputFile: template.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: ewarm
  ICCARM.CCIncludePath2: ../../../../../../../../CoX\CoX_Peripheral\CoX_Peripheral_NUC1xx\libcox; ../../../../../../../../CoX\CoX_Peripheral\CoX_Peripheral_NUC1xx\testframe; ../../../../../../../../CoX\CoX_Peripheral\CoX_Peripheral_NUC1xx\gpio\test\suite1\src
  group CoX/CoX_Peripheral/inc
    ../../../../libcox/: xcore.h xgpio.h xhw_gpio.h xhw_ints.h xhw_memmap.h xhw_nvic.h xhw_pwm.h xhw_sysctl.h xhw_types.h xhw_uart.h xpwm.h xsysctl.h xuart.h
  group CoX/CoX_Peripheral/src
    ../../../../libcox/: xcore.c xgpio.c xpwm.c xsysctl.c xuart.c
  group CoX/Example
    ../src/: PWM_Output.c
  group ewarm
    ../../../../startup/src/: startup_ewarm.s
  group source
    ../src/: main.c
