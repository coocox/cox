# IAR project suite1.ewp, settings and files
configuration Debug_Flash (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: NUC140xE Nuvoton NUC140xE
  ICCARM.CCDefines: ewarm
  ICCARM.CCIncludePath2: ../../../../../../../CoX\CoX_Peripheral\CoX_Peripheral_NUC1xx\libcox; ../../../../../../../CoX\CoX_Peripheral\CoX_Peripheral_NUC1xx\testframe; ../../../../../../../CoX\CoX_Peripheral\CoX_Peripheral_NUC1xx\rtc\test\suite1\src
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ILINK.IlinkOutputFile: template.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\CONFIG\generic_cortex.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Debug_Ram (ARM, debug)
  as the first configuration, except:
  group CoX/CoX_Peripheral/inc
    ../../../../libcox/: xcore.h xdebug.h xgpio.h xhw_gpio.h xhw_ints.h xhw_memmap.h xhw_nvic.h xhw_rtc.h xhw_sysctl.h xhw_uart.h xrtc.h xsysctl.h
  group CoX/CoX_Peripheral/src
    ../../../../libcox/: xcore.c xgpio.c xrtc.c xsysctl.c xuart.c
  group ewarm
    ./: startup_NUC1xx.s
  group test/testcase
    ../src/: testcase.c testcase.h xrtctest.c
  group test/testframe
    ../../../../testframe/: main.c test.c test.h testport.c
