# IAR project suite1.ewp, settings and files
configuration Debug_Flash (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: NUC140xE Nuvoton NUC140xE
  ICCARM.CCDefines: ewarm; XDEBUG
  ICCARM.CCIncludePath2: ../../../../libcox; ../../../../testframe; ../../../../startup; ../src
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: template.srec
  ILINK.IlinkOutputFile: template.out
  ILINK.IlinkIcfFile: nuc1xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Debug_Ram (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: ewarm
  ICCARM.CCIncludePath2: ..\..\..\..\libcox
  ILINK.IlinkIcfFile: nuc1xx_ram.icf
  group CoX/CoX_Peripheral/inc
    ../../../../libcox/: xacmp.h xadc.h xcore.h xdebug.h xdma.h xgpio.h xhw_acmp.h xhw_adc.h xhw_dma.h xhw_gpio.h xhw_i2c.h xhw_ints.h xhw_memmap.h xhw_nvic.h xhw_pwm.h xhw_rtc.h xhw_spi.h xhw_sysctl.h xhw_timer.h xhw_types.h xhw_uart.h xhw_wdt.h xi2c.h xpwm.h xrtc.h xspi.h xsysctl.h xtimer.h xuart.h xwdt.h
  group CoX/CoX_Peripheral/src
    ../../../../libcox/: xacmp.c xadc.c xcore.c xdebug.c xdma.c xgpio.c xi2c.c xpwm.c xrtc.c xspi.c xsysctl.c xtimer.c xuart.c xwdt.c
  group ewarm
    ./: startup_ewarm.s
  group Source
    ../src/: testcase.c testcase.h xtimertest1.c xtimertest2.c xtimertest3.c
  group Test
    ../../../../testframe/: main.c test.c test.h testport.c
