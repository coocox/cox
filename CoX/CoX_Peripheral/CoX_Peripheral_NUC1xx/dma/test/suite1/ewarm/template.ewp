# IAR project template.ewp, settings and files
configuration Debug_Flash (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: NUC140xE Nuvoton NUC140xE
  ICCARM.CCDefines: ewarm
  ICCARM.CCIncludePath2: ../../../../libcox; ../../../../testframe; ../../../../pdma\test\suite1\src; ../src; ../../../../startup\src
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: template.srec
  ILINK.IlinkOutputFile: template.out
  ILINK.IlinkIcfFile: nuc1xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Debug_Ram (ARM, debug)
  as the first configuration, except:
  ICCARM.CCIncludePath2: ..\..\..\..\libcox
  ILINK.IlinkIcfFile: nuc1xx_ram.icf
  group CoX/CoX_Peripheral/inc
    ../../../../libcox/: xcore.h xdebug.h xdma.h xgpio.h xhw_dma.h xhw_gpio.h xhw_ints.h xhw_memmap.h xhw_nvic.h Xhw_sysctl.h xhw_types.h xhw_uart.h xsysctl.h xuart.h
  group CoX/CoX_Peripheral/src
    ../../../../libcox/: xcore.c xdma.c xgpio.c xsysctl.c xuart.c
  group ewarm
    ../../../../startup/src/: startup_ewarm.s
  group Source
    ../: main.c
  group test
    ../src/: dmatest00.c dmatest01.c dmatest02.c dmatest03.c testcase.c testcase.h
  group testframe
    ../../../../testframe/: test.c test.h testport.c
