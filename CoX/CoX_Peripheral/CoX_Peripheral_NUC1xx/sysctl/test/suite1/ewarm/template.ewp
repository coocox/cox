# IAR project template.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: NUC140xE Nuvoton NUC140xE
  ICCARM.CCDefines: ewarm
  ICCARM.CCIncludePath2: ../../../../libcox; ../../../../testframe; ../../../../sysctl\test\suite1\src; ../src
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: template.srec
  ILINK.IlinkOutputFile: template.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: ../../../../../../../../CoX\CoX_Peripheral\CoX_Peripheral_NUC1xx\libcox; ../../../../../../../../CoX\CoX_Peripheral\CoX_Peripheral_NUC1xx\testframe; ../../../../../../../../CoX\CoX_Peripheral\CoX_Peripheral_NUC1xx\sysctl\test\suite1\src
  ICCARM.CCOptLevel: 3
  group CoX/CoX_Periphral/inc
    ../../../../libcox/: xcore.h xdebug.h xgpio.h xhw_gpio.h xhw_ints.h xhw_memmap.h xhw_nvic.h xhw_sysctl.h xhw_types.h xhw_uart.h xsysctl.h xuart.h
  group CoX/CoX_Periphral/src
    ../../../../libcox/: xcore.c xgpio.c xsysctl.c xuart.c
  group ewarm
    ../../../../startup/src/: startup_ewarm.s
  group test/testcase
    ../src/: testcase.c testcase.h Xsysctltest.c Xsysctltest01.c Xsysctltest02.c Xsysctltest03.c
  group testframe
    ../../../../testframe/: main.c test.c test.h testport.c
