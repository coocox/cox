# Keil uVision project suite1.uvproj, settings and files
target suite1 (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: suite1 +hex
  c flags: Optim=1
  c define: xDEBUG
  c include: ..\..\..\..\libcox;..\src;..\..\..\..\testframe
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group rvmdk
    ./: startup_stm32f10x_md.s
  group CoX
    ../../../../libcox/: xcore.c xgpio.c xrtc.c xsysctl.c xuart.c
  group test
    ../src/: testcase.c xrtctest.c
  group testframe
    ../../../../testframe/: main.c test.c testport.c
