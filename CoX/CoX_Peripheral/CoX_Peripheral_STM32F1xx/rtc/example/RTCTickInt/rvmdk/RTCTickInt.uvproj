# Keil uVision project RTCTickInt.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: RTCTickInt
  c flags: Optim=1
  c define: xDEBUG
  c include: ..\..\..\..\libcox;..\src
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group rvmdk
    ./: startup_stm32f10x_md.s
  group Cox
    ../../../../libcox/: xcore.c xgpio.c xrtc.c xsysctl.c xuart.c xdebug.c
  group example
    ../src/: main.c RTCTickInt.c
