# Keil uVision project test.uvproj, settings and files
target Debug_Flash (ARM-ADS)
  device: STM32F100VB STMicroelectronics
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: template +hex
  c flags: Optim=1
  c define: rvmdk
  c include: ..\..\..\..\libcox;..\..\..\..\startup\src;..\..\..\..\testframe;..\src
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --entry ResetHandler
  group rvmdk
    ../../../../startup/src/: startup_rvmdk.s
  group libcox_inc
    ../../../../libcox/: xcore.h xdebug.h xgpio.h xhw_ints.h xhw_memmap.h xhw_nvic.h xhw_types.h xspi.h xsysctl.h xuart.h xhw_uart.h xhw_gpio.h xhw_spi.h xhw_sysctl.h
  group libcox_src
    ../../../../libcox/: xcore.c xdebug.c xuart.c xgpio.c xspi.c xsysctl.c
  group Source
    ../src/: spitest00.c testcase.c testcase.h spitest01.c
  group testframe
    ../../../../testframe/: main.c test.c test.h testport.c
target Debug_Ram (ARM-ADS)
  device: NUC140LD3AN Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x0FFFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: template
  c flags: Optim=1 OneElfS=1
  c include: ..\..\..\..\libcox
  memory RVCT4: ROM 0x20000000 size 0x2000
  memory RVCT9: RAM 0x20002000 size 0x2000
  scatter file: .\nuc1xx_ram.sct
  link misc: --entry ResetHandler
