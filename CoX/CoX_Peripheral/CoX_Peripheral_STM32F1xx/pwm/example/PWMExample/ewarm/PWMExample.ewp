# IAR project PWMExample.ewp, settings and files
configuration Debug_Flash (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: STM32F10xxB ST STM32F10xxB
  ICCARM.CCDefines: ewarm
  ICCARM.CCIncludePath2: ../../../../libcox; ../src
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: PWMExample.srec
  ILINK.IlinkOutputFile: template.out
  ILINK.IlinkIcfFile: PWMExample.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Debug_Ram (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: NUC140xE Nuvoton NUC140xE
  ICCARM.CCIncludePath2: ..\..\..\..\libcox
  ILINK.IlinkIcfFile: nuc1xx_ram.icf
  group CoX/CoX_Peripheral/inc
    ../../../../libcox/: xcore.h xdebug.h xgpio.h xhw_gpio.h xhw_ints.h xhw_memmap.h xhw_nvic.h xhw_sysctl.h xhw_timer.h xhw_types.h xhw_uart.h xpwm.h xsysctl.h xuart.h
  group CoX/CoX_Peripheral/src
    ../../../../libcox/: xcore.c xgpio.c xpwm.c xsysctl.c xuart.c
  group ewarm
    ../../../../startup/src/: startup_ewarm.s
  group example
    ../src/: PWMExample.c
  group Source
    ../: main.c
