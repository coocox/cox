# IAR project template.ewp, settings and files
configuration Debug_Flash (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: STM32F10xxB ST STM32F10xxB
  ICCARM.CCDefines: ewarm
  ICCARM.CCIncludePath2: ../../../../libcox; ../../../../testframe; ../../../../pdma\test\suite1\src; ../src; ../../../../startup\src
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: template.srec
  ILINK.IlinkOutputFile: template.out
  ILINK.IlinkIcfFile: template.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Debug_Ram (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: NUC140xE Nuvoton NUC140xE
  ICCARM.CCIncludePath2: ..\..\..\..\libcox
  ILINK.IlinkIcfFile: nuc1xx_ram.icf
  group CoX/CoX_Peripheral/inc
    ../../../../libcox/: xcore.h xdebug.h xdma.h xgpio.h xhw_dma.h xhw_gpio.h xhw_ints.h xhw_memmap.h xhw_nvic.h xhw_spi.h xhw_sysctl.h xhw_types.h xhw_uart.h xspi.h xsysctl.h xuart.h
  group CoX/CoX_Peripheral/src
    ../../../../libcox/: xcore.c xdma.c xgpio.c xspi.c xsysctl.c xuart.c
  group ewarm
    ../../../../startup/src/: startup_ewarm.s
  group test/testcase
    ../src/: dmatest00.c dmatest01.c dmatest02.c dmatest03.c dmatest04.c testcase.c testcase.h
  group test/testframe
    ../../../../testframe/: main.c test.c test.h testport.c
