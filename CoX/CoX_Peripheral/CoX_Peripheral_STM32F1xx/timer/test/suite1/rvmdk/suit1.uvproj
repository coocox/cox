# Keil uVision project suit1.uvproj, settings and files
target Debug_Flash (ARM-ADS)
  device: STM32F103VB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: template
  c flags: Optim=1
  c define: rvmdk
  c include: ..\..\..\..\libcox;..\..\..\test;..\..\..\..\testframe;..\..\..\..\startup\src;..\src
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --entry ResetHandler
  group rvmdk
    ../../../../startup/src/: startup_rvmdk.s
  group libcox_inc
    ../../../../libcox/: xcore.h xdebug.h xgpio.h xhw_gpio.h xhw_ints.h xhw_memmap.h xhw_nvic.h xhw_sysctl.h xhw_types.h xhw_uart.h xsysctl.h xuart.h xtimer.h xhw_timer.h
  group libcox_src
    ../../../../libcox/: xcore.c xgpio.c xsysctl.c xuart.c xdebug.c xtimer.c
  group Source
    ../../../../testframe/: main.c test.c test.h testport.c
  group test
    ../src/: testcase.c testcase.h
target Debug_Ram (ARM-ADS)
  device: NUC140LD3AN Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x0FFFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: template
  c flags: Optim=1 OneElfS=1
  c include: ..\..\..\..\libcox
  memory RVCT4: ROM 0x20000000 size 0x2000
  memory RVCT9: RAM 0x20002000 size 0x2000
  scatter file: .\nuc1xx_ram.sct
  link misc: --entry Reset_Handler
