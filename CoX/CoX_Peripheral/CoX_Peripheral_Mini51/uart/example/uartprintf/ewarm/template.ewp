# IAR project template.ewp, settings and files
configuration Debug_Flash (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: Mini51 series Nuvoton Mini51 series (Mini51,Mini52,Mini54)
  ICCARM.CCDefines: ewarm; xDEBUG
  ICCARM.CCIncludePath2: ../../../../libcox; ../../../../startup; ../src
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: template.srec
  ILINK.IlinkOutputFile: template.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Debug_Ram (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: NUC100 series Nuvoton NUC100 series (NUC100,NUC101,NUC102,NUC120,NUC122,NUC130,NUC140)
  ICCARM.CCDefines: ewarm
  ILINK.IlinkIcfFile: stellaris_ram.icf
  group CoX/CoX_Peripheral/inc
    ../../../../libcox/: xcore.h xdebug.h xgpio.h xhw_gpio.h xhw_ints.h xhw_memmap.h xhw_nvic.h xhw_sysctl.h xhw_types.h xhw_uart.h xsysctl.h xuart.h
  group CoX/CoX_Peripheral/src
    ../../../../libcox/: xcore.c xdebug.c xgpio.c xsysctl.c xuart.c
  group CoX/example
    ../src/: uartprintf.c
  group ewarm
    ../../../../startup/src/: startup_ewarm.s
  group Source
    ../src/: main.c
