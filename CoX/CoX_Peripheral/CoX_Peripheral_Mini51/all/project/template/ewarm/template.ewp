# IAR project template.ewp, settings and files
configuration Debug_Flash (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: Mini51 series Nuvoton Mini51 series (Mini51,Mini52,Mini54)
  ICCARM.CCDefines: ewarm
  ICCARM.CCIncludePath2: ..\..\..\..\libcox
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: template.srec
  ILINK.IlinkOutputFile: template.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Debug_Ram (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: NUC140xE Nuvoton NUC140xE
  ILINK.IlinkIcfFile: nuc1xx_ram.icf
  group CoX/CoX_Peripheral/inc
    ../../../../libcox/: xacmp.h xadc.h xcore.h xdebug.h xgpio.h xhw_acmp.h xhw_adc.h xhw_gpio.h xhw_i2c.h xhw_ints.h xhw_memmap.h xhw_nvic.h xhw_pwm.h xhw_spi.h xhw_sysctl.h xhw_timer.h xhw_types.h xhw_uart.h xhw_wdt.h xi2c.h xpwm.h xspi.h xsysctl.h xtimer.h xuart.h xwdt.h
  group CoX/CoX_Peripheral/src
    ../../../../libcox/: xacmp.c xadc.c xcore.c xdebug.c xgpio.c xi2c.c xpwm.c xspi.c xsysctl.c xtimer.c xuart.c xwdt.c
  group ewarm
    ./: startup_ewarm.s
  group Source
    ../: main.c
