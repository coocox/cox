# IAR project template.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK20DX64xxx7 Freescale MK20DX64xxx7
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ewarm
  ICCARM.CCIncludePath2: ../../../../libcox; ../../../../testframe; ../../../../sysctl\test\suite1\src; ../src
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: template.srec
  ILINK.IlinkOutputFile: template.out
  ILINK.IlinkIcfFile: F:\CoX_Peripheral_KLx\sysctl\test\suite1\ewarm\16KB_RAM.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: ../../../../../../../../CoX\CoX_Peripheral\CoX_Peripheral_NUC1xx\libcox; ../../../../../../../../CoX\CoX_Peripheral\CoX_Peripheral_NUC1xx\testframe; ../../../../../../../../CoX\CoX_Peripheral\CoX_Peripheral_NUC1xx\sysctl\test\suite1\src
  ICCARM.CCOptLevel: 3
  group CoX/CoX_Peripheral/inc
    ../../../../libcox/: xadc.h xcore.h xdebug.h xgpio.h xhw_adc.h xhw_gpio.h xhw_ints.h xhw_memmap.h xhw_nvic.h xhw_sysctl.h xhw_types.h xsysctl.h
  group CoX/CoX_Peripheral/src
    ../../../../libcox/: xcore.c xgpio.c xsysctl.c
  group ewarm
    ../../../../startup/src/: startup_ewarm.s
  group test/testcase
    ../src/: testcase.c testcase.h Xsysctltest01.c Xsysctltest02.c Xsysctltest03.c
  group test/testframe
    ../../../../testframe/: main.c test.c test.h testport.c
