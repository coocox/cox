# Keil uVision project template.uvproj, settings and files
target Debug_Flash (ARM-ADS)
  device: Cortex-M0+ ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0+") ESEL ELITTLE
  output: template
  c flags: Optim=1
  c define: XDEBUG rvmdk
  c include: ..\..\..\..\libcox
  link misc: --entry ResetHandler
  group rvmdk
    ./: startup_rvmdk.s
  group libcox_inc
    ../../../../libcox/: xadc.h xcore.h xdebug.h xgpio.h xhw_adc.h xhw_gpio.h xhw_ints.h xhw_memmap.h xhw_nvic.h xhw_spi.h xhw_sysctl.h xhw_types.h xhw_uart.h xpwm.h xspi.h xsysctl.h xuart.h xacmp.h xhw_acmp.h xhw_tpm.h xhw_i2c.h xi2c.h xdma.h xhw_dma.h xhw_rtc.h xhw_wdt.h xrtc.h xwdt.h
  group libcox_src
    ../../../../libcox/: xadc.c xcore.c xgpio.c xpwm.c xspi.c xsysctl.c xuart.c xacmp.c xdebug.c xi2c.c xdma.c xrtc.c xwdt.c
  group Source
    ../: main.c
target Debug_Ram (ARM-ADS)
  device: NUC140LD3AN Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x0FFFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: template
  c flags: Optim=1 OneElfS=1
  c include: ..\..\..\..\libcox
  memory RVCT4: ROM 0x20000000 size 0x2000
  memory RVCT9: RAM 0x20002000 size 0x2000
  scatter file: .\nuc1xx_ram.sct
  link misc: --entry ResetHandler
