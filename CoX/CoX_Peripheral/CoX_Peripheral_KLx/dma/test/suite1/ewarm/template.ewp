# IAR project template.ewp, settings and files
configuration Debug_Flash (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ewarm; xDEBUG
  ICCARM.CCIncludePath2: ../../../../libcox; ../../../../testframe; ../../../../dma\test\suite1\src; ../src; ../../../../startup\src
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: template.srec
  ILINK.IlinkOutputFile: template.out
  ILINK.IlinkIcfFile: 128KB_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Debug_Ram (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: ewarm
  ICCARM.CCIncludePath2: ..\..\..\..\libcox
  ILINK.IlinkIcfFile: nuc1xx_ram.icf
  group CoX/CoX_Peripheral/inc
    ../../../../libcox/: xcore.h xdebug.h xdma.h xgpio.h xhw_dma.h xhw_gpio.h xhw_ints.h xhw_memmap.h xhw_nvic.h xhw_sysctl.h xhw_types.h xhw_uart.h xsysctl.h xuart.h
  group CoX/CoX_Peripheral/src
    ../../../../libcox/: xcore.c xdma.c xgpio.c xsysctl.c xuart.c
  group ewarm
    ../../../../startup/src/: startup_ewarm.s
  group test/testcase
    ../src/: dmatest00.c dmatest01.c dmatest02.c dmatest03.c dmatest04.c testcase.c testcase.h
  group test/testframe
    ../../../../testframe/: main.c test.c test.h testport.c
