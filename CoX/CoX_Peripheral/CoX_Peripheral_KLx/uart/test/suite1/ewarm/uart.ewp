# IAR project uart.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ewarm
  ICCARM.CCIncludePath2: ..\..\..\..\libcox\; ..\..\..\..\testframe\; ..\..\..\..\uart\test\suite1\src\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: uart.out
  ILINK.IlinkIcfFile: F:\CoX_Peripheral_KLxx\startup\config files\16KB_RAM.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Cox
    ../../../../libcox/: xcore.c xdebug.c xgpio.c xsysctl.c xuart.c
  group startup
    ../../../../startup/: startup_ewarm.s
  group Testcase
    ../src/: testcase.c xuarttest03.c
  group Testframe
    ../../../../testframe/: main.c test.c testport.c
