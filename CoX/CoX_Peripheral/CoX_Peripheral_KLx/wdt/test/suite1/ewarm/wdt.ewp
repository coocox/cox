# IAR project wdt.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ewarm
  ICCARM.CCIncludePath2: ..\..\..\..\libcox\; ..\..\..\..\testframe\; ..\..\..\..\uart\test\suite1\src\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: wdt.out
  ILINK.IlinkIcfFile: E:\xuesong\cox\cox\CoX\CoX_Peripheral\CoX_Peripheral_KLxx\startup\config files\16KB_RAM.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group CoxLib/inc
    ../../../../libcox/: xadc.h xcore.h xdebug.h xgpio.h xhw_adc.h xhw_gpio.h xhw_i2c.h xhw_ints.h xhw_memmap.h xhw_nvic.h xhw_sysctl.h xhw_types.h xhw_uart.h xhw_wdt.h xi2c.h xsysctl.h xuart.h xwdt.h
  group CoxLib/src
    ../../../../libcox/: xcore.c xdebug.c xgpio.c xsysctl.c xuart.c xwdt.c
  group Startup
    ../../../../startup/src/: startup_ewarm.s
  group TestCase
    ../src/: testcase.c wdttest00.c
  group TestFrame
    ../../../../testframe/: main.c test.c testport.c
