# IAR project RTCTickInt.ewp, settings and files
configuration Debug_Flash (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: ewarm
  ICCARM.CCIncludePath2: ../; ../../../../../../../CoX\CoX_Peripheral\CoX_Peripheral_KLx\libcox; ../../../../../../../CoX\CoX_Peripheral\CoX_Peripheral_KLx\startup; ../../../../../../../CoX\CoX_Peripheral\CoX_Peripheral_KLx\rtc\example\RTCTickInt\src
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: RTCTickInt.srec
  ILINK.IlinkOutputFile: template.out
  ILINK.IlinkIcfFile: 16KB_RAM.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Debug_Ram (ARM, debug)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: ../../../../../../../CoX\CoX_Peripheral\CoX_Peripheral_NUC1xx\libcox; ../../../../../../../CoX\CoX_Peripheral\CoX_Peripheral_NUC1xx\testframe; ../../../../../../../CoX\CoX_Peripheral\CoX_Peripheral_NUC1xx\rtc\test\suite1\src
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\CONFIG\generic_cortex.icf
  group CoX/CoX_Peripheral/inc
    ../../../../libcox/: xcore.h xdebug.h xgpio.h xhw_gpio.h xhw_ints.h xhw_memmap.h xhw_nvic.h xhw_rtc.h xhw_sysctl.h xhw_uart.h xrtc.h xsysctl.h
  group CoX/CoX_Peripheral/src
    ../../../../libcox/: xcore.c xgpio.c xrtc.c xsysctl.c xuart.c
  group ewarm
    ../../../../startup/src/: startup_ewarm.s
  group example
    ../: main.c
    ../src/: RTCTickInt.c
