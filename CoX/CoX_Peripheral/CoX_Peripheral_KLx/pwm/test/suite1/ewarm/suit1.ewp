# IAR project suit1.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: HT32F1253 HT32F1253
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ewarm; xDEBUG; DEBUG
  ICCARM.CCIncludePath2: ../../../../libcox; ../../../../testframe; ../../../../startup/src; ../src
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: template.out
  ILINK.IlinkIcfFile: E:\cox\CoX\CoX_Peripheral\CoX_Peripheral_KLx\pwm\test\suite1\ewarm\128KB_Pflash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  ICCARM.CCDefines: ewarm
  ICCARM.CCIncludePath2: ../../../../../../../../CoX\CoX_Peripheral\CoX_Peripheral_NUC1xx\libcox; ../../../../../../../../CoX\CoX_Peripheral\CoX_Peripheral_NUC1xx\testframe; ../../../../../../../../CoX\CoX_Peripheral\CoX_Peripheral_NUC1xx\gpio\test\suite1\src
  group CoX/CoX_Peripheral/inc
    ../../../../libcox/: xcore.h xdebug.h xgpio.h xhw_gpio.h xhw_ints.h xhw_memmap.h xhw_nvic.h xhw_sysctl.h xhw_tpm.h xhw_types.h xhw_uart.h xpwm.h xsysctl.h xuart.h
  group CoX/CoX_Peripheral/src
    ../../../../libcox/: xcore.c xdebug.c xgpio.c xpwm.c xsysctl.c xuart.c
  group ewarm
    ../../../../startup/src/: startup_ewarm.s
  group test/testcase
    ../src/: testcase.c testcase.h xpwmtest1.c xpwmtest2.c xpwmtest3.c
  group test/testframe
    ../../../../testframe/: main.c test.c test.h testport.c
