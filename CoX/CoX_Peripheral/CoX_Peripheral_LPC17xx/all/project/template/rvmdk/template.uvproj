# Keil uVision project template.uvproj, settings and files
target Debug_Flash (ARM-ADS)
  device: STM32F103VB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: template
  c flags: Optim=1
  c define: XDEBUG
  c include: ..\..\..\..\libcox
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --entry ResetHandler
  group rvmdk
    ./: startup_rvmdk.s
  group libcox_inc
    ../../../../libcox/: xhw_i2c.h xhw_ints.h xhw_memmap.h xhw_nvic.h xhw_rtc.h xhw_spi.h xhw_sysctl.h xhw_types.h xhw_uart.h xi2c.h xpwm.h xrtc.h xspi.h xsysctl.h xtimer.h xuart.h xwdt.h xacmp.h xadc.h xcore.h xdebug.h xdma.h xgpio.h xhw_dma.h xhw_gpio.h xhw_adc.h xhw_config.h xhw_timer.h xhw_wdt.h
  group libcox_src
    ../../../../libcox/: xcore.c xdebug.c xdma.c xgpio.c xi2c.c xrtc.c xspi.c xsysctl.c xuart.c xadc.c xpwm.c xtimer.c xwdt.c
  group Source
    ../: main.c
target Debug_Ram (ARM-ADS)
  device: STM32F103VB STMicroelectronics
  cpu: as above
  output: template
  c flags: Optim=1 OneElfS=1
  c include: ..\..\..\..\libcox
  memory RVCT4: ROM 0x20000000 size 0x3000
  memory RVCT9: RAM 0x20003000 size 0x2000
  link misc: --entry ResetHandler
