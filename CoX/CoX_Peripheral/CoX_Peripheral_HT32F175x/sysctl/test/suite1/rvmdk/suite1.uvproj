# Keil uVision project suite1.uvproj, settings and files
target Debug_Flash (ARM-ADS)
  device: HT32F1755 Holtek
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x00000000-0x0001FBFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: SysCtlTest
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  c flags: Optim=1
  c define: rvmdk,xDebug
  c include: ..\..\..\..\libcox;..\src;..\..\..\..\testframe
  memory RVCT4: ROM 0x0 size 0x1fc00
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --entry ResetHandler
  group rvmdk
    ../../../../startup/src/: startup_rvmdk.s
  group libcox
    ../../../../libcox/: xcore.c xcore.h xdebug.h xhw_sysctl.h xhw_types.h xsysctl.c xsysctl.h xhw_nvic.h xhw_ints.h xhw_memmap.h xgpio.c xgpio.h xhw_gpio.h xhw_uart.h xuart.c xuart.h
  group test
    ../../../../testframe/: main.c test.c test.h testport.c
  group testcase
    ../src/: sysctltest00.c testcase.c testcase.h sysctltest04.c sysctltest05.c sysctltest03.c sysctltest01.c sysctltest02.c
target Debug_Ram (ARM-ADS)
  device: NUC140LE3AN Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: template
  c flags: Optim=1
  c include: ..\..\..\..\libcox;..\src;..\..\..\..\testframe
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --entry Reset_Handler
