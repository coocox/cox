# Keil uVision project template.uvproj, settings and files
target Debug_Flash (ARM-ADS)
  device: HT32F1755 Holtek
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x00000000-0x0001FBFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: template
  c flags: Optim=1
  c define: XDEBUG
  c include: ..\..\..\..\libcox
  memory RVCT4: ROM 0x0 size 0x1fc00
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: .\HT32F175x_flash.sct
  link misc: --entry ResetHandler
  group rvmdk
    ./: startup_rvmdk.s
  group libcox_inc
    ../../../../libcox/: xadc.h xcore.h xdebug.h xgpio.h xhw_adc.h xhw_gpio.h xhw_i2c.h xhw_ints.h xhw_memmap.h xhw_nvic.h xhw_rtc.h xhw_spi.h xhw_sysctl.h xhw_types.h xhw_uart.h xi2c.h xrtc.h xspi.h xsysctl.h xuart.h xacmp.h xhw_acmp.h xhw_wdt.h xwdt.h xhw_timer.h xpwm.h xtimer.h
  group libcox_src
    ../../../../libcox/: xadc.c xcore.c xgpio.c xi2c.c xrtc.c xspi.c xsysctl.c xuart.c xacmp.c xdebug.c xwdt.c xpwm.c xtimer.c
  group Source
    ../: main.c
target Debug_Ram (ARM-ADS)
  device: HT32F1755 Holtek
  cpu: as above
  output: template
  c flags: Optim=1 OneElfS=1
  c include: ..\..\..\..\libcox
  memory RVCT4: ROM 0x0 size 0x1fc00
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: .\HT32F175x_ram.sct
  link misc: --entry ResetHandler
