# IAR project suite1.ewp, settings and files
configuration Debug_Flash (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: HT32F1253 HT32F1253
  ICCARM.CCDefines: ewarm; xDEBUG
  ICCARM.CCIncludePath2: ../../../../libcox; ../../../../testframe; ../../../../startup; ../src
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: suite1.srec
  ILINK.IlinkOutputFile: template.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Debug_Ram (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: NUC140xE Nuvoton NUC140xE
  ICCARM.CCDefines: ewarm
  ICCARM.CCIncludePath2: ..\..\..\..\libcox
  ILINK.IlinkIcfFile: nuc1xx_ram.icf
  group CoX/CoX_Peripheral/inc
    ../../../../libcox/: xcore.h xdebug.h xgpio.h xhw_gpio.h xhw_ints.h xhw_memmap.h xhw_nvic.h xhw_sysctl.h xhw_timer.h xhw_types.h xsysctl.h xtimer.h xuart.h
  group CoX/CoX_Peripheral/src
    ../../../../libcox/: xcore.c xdebug.c xgpio.c xsysctl.c xtimer.c xuart.c
  group test/testcase
    ../src/: testcase.c testcase.h xtimertest1.c
  group test/testframe
    ../../../../testframe/: main.c test.c test.h testport.c
