# Keil uVision project suite1.uvproj, settings and files
target Debug_Flash (ARM-ADS)
  device: NUC140VE3AN Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: uart
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  c flags: Optim=1
  c include: ..\..\..\..\libcox;..\src;..\..\..\..\testframe
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --entry Reset_Handler
  group rvmdk
    ./: startup_NUC1xx.s
  group libcox
    ../../../../libcox/: xcore.c xcore.h xdebug.h xgpio.c xgpio.h xhw_gpio.h xhw_ints.h xhw_memmap.h xhw_nvic.h xhw_sysctl.h xhw_types.h xhw_uart.h xsysctl.c xsysctl.h xuart.h
  group test
    ../../../../libcox/: xuart.c
    ../../../../testframe/: main.c test.c testport.c test.h
  group testcase
    ../src/: testcase.h testcase.c xuarttest.c
target Debug_Ram (ARM-ADS)
  device: NUC140LE3AN Nuvoton
  cpu: as above
  output: template
  c flags: Optim=1
  c include: ..\..\..\..\libcox;..\src;..\..\..\..\testframe
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --entry Reset_Handler
