# Keil uVision project suit1.uvproj, settings and files
target Debug_Flash (ARM-ADS)
  device: NUC140LE3AN Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: template
  c flags: Optim=1
  c define: XDEBUG
  c include: ..\..\..\..\libcox;..\..\..\..\testframe;..\src;..\..\..\..\startup\src
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: .\nuc1xx_flash.sct
  link misc: --entry ResetHandler
  group rvmdk
    ./: startup_rvmdk.s
  group libcox_inc
    ../../../../libcox/: xcore.h xdebug.h xgpio.h xhw_gpio.h xhw_i2c.h xhw_ints.h xhw_memmap.h xhw_nvic.h xhw_spi.h xhw_sysctl.h xhw_timer.h xhw_types.h xhw_uart.h xi2c.h xspi.h xsysctl.h xtimer.h xuart.h
  group libcox_src
    ../../../../libcox/: xcore.c xgpio.c xi2c.c xspi.c xsysctl.c xtimer.c xuart.c xdebug.c
  group Source
    ../src/: testcase.c testcase.h xgpiotest1.c xgpiotest2.c
  group testframe
    ../../../../testframe/: main.c test.c test.h testport.c
target Debug_Ram (ARM-ADS)
  device: NUC140LD3AN Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x0FFFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: template
  c flags: Optim=1 OneElfS=1
  c include: ..\..\..\..\libcox
  memory RVCT4: ROM 0x20000000 size 0x2000
  memory RVCT9: RAM 0x20002000 size 0x2000
  scatter file: .\nuc1xx_ram.sct
  link misc: --entry Reset_Handler
