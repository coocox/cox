# Keil uVision project suit1.uvproj, settings and files
target Debug_Flash (ARM-ADS)
  device: HT32F1253 Holtek
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x00000000-0x00007BFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: template +hex
  c flags: Optim=1
  c define: rvmdk
  c include: ..\..\..\..\libcox;..\..\..\..\testframe;..\src;..\..\..\..\startup\src
  memory RVCT4: ROM 0x0 size 0x7c00
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --entry ResetHandler
  group rvmdk
    ../../../../startup/src/: startup_rvmdk.s
  group libcox_inc
    ../../../../libcox/: xcore.h xdebug.h xgpio.h xhw_gpio.h xhw_ints.h xhw_memmap.h xhw_nvic.h xhw_sysctl.h xhw_types.h xsysctl.h xuart.h xhw_uart.h
  group libcox_src
    ../../../../libcox/: xcore.c xgpio.c xspi.c xsysctl.c xdebug.c xuart.c
  group Source
    ../src/: xgpiotest1.c testcase.c testcase.h xgpiotest2.c
  group testframe
    ../../../../testframe/: main.c test.c test.h testport.c
target Debug_Ram (ARM-ADS)
  device: NUC140LD3AN Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x0FFFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: template
  c flags: Optim=1 OneElfS=1
  c include: ..\..\..\..\libcox
  memory RVCT4: ROM 0x20000000 size 0x2000
  memory RVCT9: RAM 0x20002000 size 0x2000
  scatter file: .\nuc1xx_ram.sct
  link misc: --entry Reset_Handler
