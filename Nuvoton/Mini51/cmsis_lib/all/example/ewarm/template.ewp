# IAR project template.ewp, settings and files
configuration Debug_Flash (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: NUC140xE Nuvoton NUC140xE
  ICCARM.CCDefines: ewarm
  ICCARM.CCIncludePath2: ..\..\..\lib\include; ..\..\..\lib\cmsis_core; ..\..\..\lib\cmsis_boot\startup\iar; ..\..\..\lib\cmsis_boot
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: template.srec
  ILINK.IlinkOutputFile: template.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Debug_Ram (ARM, debug)
  as the first configuration, except:
  ICCARM.CCIncludePath2: ..\..\..\..\lib\Include; ..\..\..\..\lib\Include\Driver; ..\..\..\..\lib\Include\System; ..\..\..\..\lib\cmsis_boot; ..\..\..\..\lib\cmsis_core
  OBJCOPY.OOCOutputFile: sample_sys.srec
  ILINK.IlinkIcfFile: nuc1xx_ram.icf
  group cmsis_boot
    ../../../lib/cmsis_boot/: MINI51.h system_MINI51.c system_MINI51.h
  group cmsis_boot/startup
    ../../../lib/cmsis_boot/startup/src/: startup_Mini51Series.c
  group cmsis_core
    ../../../lib/cmsis_core/: core_cm0.c core_cm0.h
  group cmsis_lib/include
    ../../../lib/Include/: DrvADC.h DrvFMC.h DrvGPIO.h DrvI2C.h DrvPWM.h DrvSPI.h DrvSYS.h DrvTIMER.h DrvUART.h
  group cmsis_lib/source
    ../../../lib/Source/: DrvADC.c DrvFMC.c DrvGPIO.c DrvI2C.c DrvPWM.c DrvSPI.c DrvSYS.c DrvTIMER.c DrvUART.c
  group document/acmp
    ../../../acmp/document/: acmp.xml description.html
  group document/adc
    ../../../adc/document/: adc.xml description.html
  group document/fmc
    ../../../fmc/document/: description.html fmc.xml
  group document/gpio
    ../../../gpio/document/: description.html gpio.xml
  group document/i2c
    ../../../i2c/document/: description.html i2c.xml
  group document/pwm
    ../../../pwm/document/: description.html pwm.xml
  group document/spi
    ../../../spi/document/: description.html spi.xml
  group document/sysctl
    ../../../sysctl/document/: description.html sysctl.xml
  group document/timer
    ../../../timer/document/: description.html timer.xml
  group document/uart
    ../../../uart/document/: description.html uart.xml
  group document/wdt
    ../../../wdt/document/: description.html wdt.xml
  group Source
    ../src/: main.c
